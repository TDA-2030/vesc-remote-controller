# IAR project SkateboardTx.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0
  ICCSTM8.CCIncludePath2: ..\Source\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SkateboardTx.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group HARDWARE
    ../Source/src/: 24l01.c adc.c exti.c key.c led.c multi_button.c oled.c stm8s_flash.c timer.c
  group SYSTEM
    ../Source/src/: delay.c stm8s_interruput.c
  group USER
    ../Source/src/: control.c crc.c font.c gui_basic.c gui_bitmap.c gui_char.c m_settings.c main.c menu.c windows.c
